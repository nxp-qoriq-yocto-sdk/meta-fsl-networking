PRINC := "${@int(PRINC) + 1}"

SRC_URI = "git://git.am.freescale.net/gitolite/dpaa-modules/fm-ucode.git"
SRCREV = "${AUTOREV}"
