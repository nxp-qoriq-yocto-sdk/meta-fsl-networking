FILESEXTRAPATHS_prepend := "${THISDIR}/mdadm:"

SRC_URI += "file://gcc-4.9.patch"

