PR_append = "+fsl.1"

SRC_URI_append = " http://gate.crashing.org/~fray/shadow-native-block-groupadd-and-useradd.patch;name=patch"

SRC_URI[patch.md5sum] = "1751338544022df9ba8a7474ebac130b"
SRC_URI[patch.sha256sum] = "cbba71baac45f9d66bd46a7ae768557a634a323040811e65fa01ac10046fb0df"
