PRINC := "${@int(PRINC) + 1}"

SRC_URI = "git://git.am.freescale.net/gitolite/sdk/u-boot-devel.git"
SRCREV = "${AUTOREV}"
