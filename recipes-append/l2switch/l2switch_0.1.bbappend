SRC_URI = "${URL-L2SWITCH-UTIL}"
SRCREV = "${SHA-L2SWITCH-UTIL}"
