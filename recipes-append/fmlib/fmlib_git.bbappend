SRC_URI = "${URL-FMLIB}"
SRCREV = "${SHA-FMLIB}"
