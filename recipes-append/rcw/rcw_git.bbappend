SRC_URI = "${URL-RCW}"
SRCREV = "${SHA-RCW}"
