PRINC := "${@int(PRINC) + 1}"

EXTRA_OECONF = "--with-usrlibdir=${libdir}"
