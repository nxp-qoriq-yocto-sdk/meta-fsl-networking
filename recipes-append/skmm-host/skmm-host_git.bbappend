SRC_URI = "${URL-SKMM-HOST}"
SRCREV = "${SHA-SKMM-HOST}"
