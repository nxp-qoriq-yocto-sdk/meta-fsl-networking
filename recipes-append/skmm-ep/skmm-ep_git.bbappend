SRC_URI = "${URL-SKMM-EP} \
    file://add-two-missing-header-files.patch \
"
SRCREV = "${SHA-SKMM-EP}"
