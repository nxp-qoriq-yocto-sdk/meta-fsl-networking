require recipes-kernel/linux/linux-qoriq-sdk.inc

SRC_URI = "${URL-LINUX}"
SRCREV = "${SHA-LINUX}"

