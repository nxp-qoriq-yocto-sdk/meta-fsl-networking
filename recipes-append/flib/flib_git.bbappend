LIC_FILES_CHKSUM = "file://COPYING;md5=fec03257d7cba94863bd4892a6d00226"

