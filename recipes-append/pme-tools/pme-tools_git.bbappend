SRC_URI = "${URL-PME-TOOLS}"
SRCREV = "${SHA-PME-TOOLS}"
