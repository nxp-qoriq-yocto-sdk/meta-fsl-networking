SRC_URI = "${URL-LIBPPC}"
SRCREV = "${SHA-LIBPPC}"
