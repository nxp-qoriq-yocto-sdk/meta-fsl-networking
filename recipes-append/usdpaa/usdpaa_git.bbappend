SRC_URI = "${URL-USDPAA}"
SRCREV = "${SHA-USDPAA}"
