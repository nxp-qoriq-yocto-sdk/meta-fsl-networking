SRC_URI = "${URL-IPC}"
SRCREV = "${SHA-IPC}"
