SRCREV = "${SHA-CRYPTODEV}"
SRC_URI = "${URL-CRYPTODEV}"
