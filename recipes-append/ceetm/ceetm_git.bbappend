SRC_URI = "${URL-CEETM}"
SRCREV =  "${SHA-CEETM}"
