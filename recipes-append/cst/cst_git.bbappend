SRC_URI = "${URL-CST}"
SRCREV = "${SHA-CST}"
