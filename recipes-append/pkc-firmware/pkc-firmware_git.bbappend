SRC_URI = "${URL-PKC-FIRMWARE}"
SRCREV = "${SHA-PKC-FIRMWARE}"
