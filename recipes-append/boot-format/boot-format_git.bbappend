SRC_URI = "${URL-BOOT-FORMAT}"
SRCREV = "${SHA-BOOT-FORMAT}"
