SRC_URI = "${URL-PKC-HOST}"
SRCREV = "${SHA-PKC-HOST}"
