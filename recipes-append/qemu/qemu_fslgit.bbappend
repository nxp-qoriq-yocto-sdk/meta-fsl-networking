SRC_URI = "${URL-QEMU}"
SRCREV = "${SHA-QEMU}"
