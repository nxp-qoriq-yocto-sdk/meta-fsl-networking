SRC_URI = "${URL-QORIQ-DEBUG}"
SRCREV = "${SHA-QORIQ-DEBUG}"
