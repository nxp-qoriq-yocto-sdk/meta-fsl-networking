IMAGE_INSTALL += "\
    packagegroup-cloud-compute \
    memcached \
    apache2 \
    merge-files \
    mariadb \
    mysql-python \
    rsync \
    xfsprogs \
    iscsi-initiator-utils \
    openstack-demo \
    "

