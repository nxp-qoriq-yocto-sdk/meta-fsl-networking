SRC_URI = "${URL-HV-CFG}"
SRCREV = "${SHA-HV-CFG}"
