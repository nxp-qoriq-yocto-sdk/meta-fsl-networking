SRC_URI = "${URL-ETH-CONFIG}"
SRCREV = "${SHA-ETH-CONFIG}"
