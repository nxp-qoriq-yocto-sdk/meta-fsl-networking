LIC_FILES_CHKSUM = "file://COPYING;md5=75d2f6a74299640c05ae6c69ed7a4ad6"

SRC_URI = "${URL-FLIB}"
SRCREV = "${SHA-FLIB}"
