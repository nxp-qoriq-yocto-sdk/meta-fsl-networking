SRC_URI = "${URL-AUTO-RESP}"
SRCREV =  "${SHA-AUTO-RESP}"
