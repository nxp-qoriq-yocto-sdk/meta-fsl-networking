SRC_URI = "${URL-U-BOOT}"
SRCREV = "${SHA-U-BOOT}"

