SRC_URI_qoriq-ppc = "${URL-CRYPTODEV}"
SRCREV_qoriq-ppc = "${SHA-CRYPTODEV}"
