SRC_URI = "${URL-UBOOT}"
SRCREV = "${SHA-UBOOT}"
