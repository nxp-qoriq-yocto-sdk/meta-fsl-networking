SRC_URI = "${URL-USPDCP}"
SRCREV = "${SHA-USPDCP}"
