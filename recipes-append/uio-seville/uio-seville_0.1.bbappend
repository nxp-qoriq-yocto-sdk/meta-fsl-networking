SRC_URI = "${URL-L2SWITCH-UIO}"
SRCREV = "${SHA-L2SWITCH-UIO}"
