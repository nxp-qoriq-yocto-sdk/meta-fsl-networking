PRINC := "${@int(PRINC) + 2}"

SRC_URI = "${URL-HVCFG}"
SRCREV = "${SHA-HVCFG}"
