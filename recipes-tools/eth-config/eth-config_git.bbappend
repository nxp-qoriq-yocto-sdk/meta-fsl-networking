PRINC := "${@int(PRINC) + 2}"

SRC_URI = "${URL-ETHCONFIG}"
SRCREV = "${SHA-ETHCONFIG}"
