PRINC := "${@int(PRINC) + 1}"

SRC_URI = "${URL-BOOTFORMAT}"
SRCREV = "${SHA-BOOTFORMAT}"
