PRINC := "${@int(PRINC) + 1}"

SRC_URI = "${URL-FLIB}"
SRCREV = "${SHA-FLIB}"
